# Keil uVision project first_pro.uvprojx, settings and files
target first (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first_pro +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM;..\USER;..\CMSIS;..\DEVICE_LIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: startup_stm32f10x_md.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group USER
    ./: delay.c main.c stm32f10x_it.c moto.c usart.c exti.c pwn.c uw.c sg90.c trace.c xunji.c follow.c
